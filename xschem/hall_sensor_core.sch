v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {1.2V supply (logic)} 930 -770 0 0 0.2 0.2 {}
T {Stage 1 Active RC filter (OTA-C)} 2030 -820 0 0 0.4 0.4 {}
T {Stage 2 Active RC filter (OTA-C)} 2490 -820 0 0 0.4 0.4 {}
T {Stage 3 Active RC filter (OTA-C)} 2920 -820 0 0 0.4 0.4 {}
T {Output Amp} 3570 -750 0 0 0.4 0.4 {}
T {Output single ended} 3830 -750 0 0 0.4 0.4 {}
T {Input Amp} 1780 -770 0 0 0.4 0.4 {}
T {Spike Removal RC Filter} 1430 -810 0 0 0.4 0.4 {}
N 610 -570 690 -570 {lab=#net1}
N 630 -530 690 -530 {lab=#net2}
N 630 -530 630 -450 {lab=#net2}
N 510 -470 510 -450 {lab=#net2}
N 510 -450 630 -450 {lab=#net2}
N 670 -490 690 -490 {lab=#net3}
N 670 -490 670 -410 {lab=#net3}
N 390 -410 670 -410 {lab=#net3}
N 390 -570 390 -410 {lab=#net3}
N 390 -570 410 -570 {lab=#net3}
N 630 -610 690 -610 {lab=#net4}
N 630 -690 630 -610 {lab=#net4}
N 510 -690 630 -690 {lab=#net4}
N 510 -690 510 -670 {lab=#net4}
N 1320 -510 1320 -360 {lab=CLK}
N 840 -420 840 -400 {lab=VSS}
N 1560 -570 1560 -530 {lab=out_n}
N 1560 -670 1560 -630 {lab=out_p}
N 1560 -770 1560 -730 {lab=VSS}
N 1560 -770 1580 -770 {lab=VSS}
N 1580 -770 1580 -750 {lab=VSS}
N 1560 -470 1560 -430 {lab=VSS}
N 1220 -310 1220 -290 {lab=VSS}
N 1220 -430 1220 -410 {lab=VDD}
N 1300 -360 1320 -360 {lab=CLK}
N 1050 -360 1070 -360 {lab=!clk}
N 1050 -470 1050 -360 {lab=!clk}
N 3920 -550 3920 -530 {lab=VSS}
N 3900 -680 3900 -660 {lab=VDD}
N 3900 -680 3920 -680 {lab=VDD}
N 4030 -600 4050 -600 {lab=amp_out}
N 4050 -600 4050 -560 {lab=amp_out}
N 4050 -500 4050 -480 {lab=VSS}
N 1560 -570 1730 -570 {lab=out_n}
N 1460 -570 1560 -570 {lab=out_n}
N 1460 -630 1560 -630 {lab=out_p}
N 3720 -570 3820 -570 {lab=#net5}
N 3720 -630 3820 -630 {lab=#net6}
N 1840 -530 1840 -510 {lab=VSS}
N 1840 -690 1840 -670 {lab=VDD}
N 1840 -690 1860 -690 {lab=VDD}
N 2170 -610 2170 -590 {lab=VSS}
N 2170 -750 2170 -730 {lab=VDD}
N 2170 -750 2190 -750 {lab=VDD}
N 2300 -670 2320 -670 {lab=filter1_p}
N 2170 -390 2170 -370 {lab=VSS}
N 2170 -530 2170 -510 {lab=VDD}
N 2170 -530 2190 -530 {lab=VDD}
N 2300 -450 2320 -450 {lab=filter1_n}
N 2420 -390 2420 -370 {lab=VSS}
N 2420 -610 2420 -590 {lab=VSS}
N 1980 -480 2090 -480 {lab=amp_n}
N 1980 -700 2090 -700 {lab=amp_p}
N 1980 -700 1980 -630 {lab=amp_p}
N 2420 -480 2420 -450 {lab=filter1_n}
N 2420 -700 2420 -670 {lab=filter1_p}
N 2320 -670 2420 -670 {lab=filter1_p}
N 2320 -450 2420 -450 {lab=filter1_n}
N 1560 -630 1730 -630 {lab=out_p}
N 1920 -570 1980 -570 {lab=amp_n}
N 1920 -630 1980 -630 {lab=amp_p}
N 2220 -410 2220 -390 {lab=filter1_n}
N 2220 -390 2320 -390 {lab=filter1_n}
N 2320 -450 2320 -390 {lab=filter1_n}
N 2120 -370 2120 -350 {lab=OTA_C_Bias}
N 2120 -590 2120 -570 {lab=OTA_C_Bias}
N 2220 -630 2220 -610 {lab=filter1_p}
N 2220 -610 2320 -610 {lab=filter1_p}
N 2320 -670 2320 -610 {lab=filter1_p}
N 2650 -230 2650 -210 {lab=OTA_C_Bias}
N 2610 -90 2610 -70 {lab=VSS}
N 2570 -230 2570 -210 {lab=VDD}
N 2620 -610 2620 -590 {lab=VSS}
N 2620 -750 2620 -730 {lab=VDD}
N 2620 -750 2640 -750 {lab=VDD}
N 2750 -670 2770 -670 {lab=filter2_p}
N 2620 -390 2620 -370 {lab=VSS}
N 2620 -530 2620 -510 {lab=VDD}
N 2620 -530 2640 -530 {lab=VDD}
N 2870 -390 2870 -370 {lab=VSS}
N 2870 -610 2870 -590 {lab=VSS}
N 2420 -480 2540 -480 {lab=filter1_n}
N 2420 -700 2540 -700 {lab=filter1_p}
N 2670 -410 2670 -390 {lab=filter2_n}
N 2670 -390 2770 -390 {lab=filter2_n}
N 2770 -450 2770 -390 {lab=filter2_n}
N 2750 -450 2770 -450 {lab=filter2_n}
N 2670 -630 2670 -610 {lab=filter2_p}
N 2670 -610 2770 -610 {lab=filter2_p}
N 2770 -670 2770 -610 {lab=filter2_p}
N 2570 -590 2570 -570 {lab=OTA_C_Bias}
N 2570 -370 2570 -350 {lab=OTA_C_Bias}
N 2870 -480 2870 -450 {lab=filter2_n}
N 2870 -700 2870 -670 {lab=filter2_p}
N 3070 -610 3070 -590 {lab=VSS}
N 3070 -750 3070 -730 {lab=VDD}
N 3070 -750 3090 -750 {lab=VDD}
N 3200 -670 3220 -670 {lab=filter3_p}
N 3070 -390 3070 -370 {lab=VSS}
N 3070 -530 3070 -510 {lab=VDD}
N 3070 -530 3090 -530 {lab=VDD}
N 3320 -390 3320 -370 {lab=VSS}
N 3320 -610 3320 -590 {lab=VSS}
N 2870 -480 2990 -480 {lab=filter2_n}
N 2870 -700 2990 -700 {lab=filter2_p}
N 3120 -410 3120 -390 {lab=filter3_n}
N 3120 -390 3220 -390 {lab=filter3_n}
N 3220 -450 3220 -390 {lab=filter3_n}
N 3200 -450 3220 -450 {lab=filter3_n}
N 3120 -630 3120 -610 {lab=filter3_p}
N 3120 -610 3220 -610 {lab=filter3_p}
N 3220 -670 3220 -610 {lab=filter3_p}
N 3020 -590 3020 -570 {lab=OTA_C_Bias}
N 3020 -370 3020 -350 {lab=OTA_C_Bias}
N 2770 -450 2870 -450 {lab=filter2_n}
N 2770 -670 2870 -670 {lab=filter2_p}
N 1980 -570 1980 -480 {lab=amp_n}
N 3640 -530 3640 -510 {lab=VSS}
N 3640 -690 3640 -670 {lab=VDD}
N 3640 -690 3660 -690 {lab=VDD}
N 990 -570 1400 -570 {lab=#net7}
N 3510 -570 3510 -450 {lab=filter3_n}
N 3510 -570 3530 -570 {lab=filter3_n}
N 3510 -670 3510 -630 {lab=filter3_p}
N 3510 -630 3530 -630 {lab=filter3_p}
N 3220 -450 3510 -450 {lab=filter3_n}
N 3220 -670 3510 -670 {lab=filter3_p}
N 4880 -600 4900 -600 {lab=#net8}
N 4580 -600 4600 -600 {lab=#net9}
N 4480 -600 4500 -600 {lab=#net10}
N 4740 -1440 4760 -1440 {lab=COMP2}
N 4670 -1380 4670 -1370 {lab=VSS}
N 4670 -1510 4670 -1500 {lab=VDD}
N 4840 -1340 4860 -1340 {lab=COMP3}
N 4770 -1280 4770 -1270 {lab=VSS}
N 4770 -1410 4770 -1400 {lab=VDD}
N 4560 -600 4580 -600 {lab=#net9}
N 4680 -1340 4700 -1340 {lab=#net11}
N 4580 -1440 4600 -1440 {lab=#net12}
N 4680 -600 4700 -600 {lab=#net13}
N 4940 -1240 4960 -1240 {lab=COMP4}
N 4870 -1180 4870 -1170 {lab=VSS}
N 4870 -1310 4870 -1300 {lab=VDD}
N 5040 -1140 5060 -1140 {lab=COMP5}
N 4970 -1080 4970 -1070 {lab=VSS}
N 4970 -1210 4970 -1200 {lab=VDD}
N 5140 -1040 5160 -1040 {lab=COMP6}
N 5070 -980 5070 -970 {lab=VSS}
N 5070 -1110 5070 -1100 {lab=VDD}
N 5240 -940 5260 -940 {lab=COMP7}
N 5170 -880 5170 -870 {lab=VSS}
N 5170 -1010 5170 -1000 {lab=VDD}
N 4980 -1040 5000 -1040 {lab=#net14}
N 5340 -840 5360 -840 {lab=COMP8}
N 5270 -780 5270 -770 {lab=VSS}
N 5270 -910 5270 -900 {lab=VDD}
N 4640 -1540 4660 -1540 {lab=COMP1}
N 4570 -1480 4570 -1470 {lab=VSS}
N 4570 -1610 4570 -1600 {lab=VDD}
N 4480 -1540 4500 -1540 {lab=#net15}
N 4660 -600 4680 -600 {lab=#net13}
N 5080 -600 5100 -600 {lab=#net16}
N 4980 -600 5000 -600 {lab=#net17}
N 4780 -600 4800 -600 {lab=#net18}
N 4760 -600 4780 -600 {lab=#net18}
N 4860 -600 4880 -600 {lab=#net8}
N 4960 -600 4980 -600 {lab=#net17}
N 5060 -600 5080 -600 {lab=#net16}
N 5160 -600 5180 -600 {lab=#net19}
N 5180 -600 5180 -580 {lab=#net19}
N 5180 -520 5180 -460 {lab=#net20}
N 4480 -680 4480 -600 {lab=#net10}
N 4580 -680 4580 -600 {lab=#net9}
N 4680 -680 4680 -600 {lab=#net13}
N 4780 -680 4780 -600 {lab=#net18}
N 4880 -680 4880 -600 {lab=#net8}
N 4980 -680 4980 -600 {lab=#net17}
N 5080 -680 5080 -600 {lab=#net16}
N 5180 -680 5180 -600 {lab=#net19}
N 4780 -1240 4800 -1240 {lab=#net21}
N 4880 -1140 4900 -1140 {lab=#net22}
N 5080 -940 5100 -940 {lab=#net23}
N 5180 -840 5200 -840 {lab=#net24}
N 5180 -840 5180 -740 {lab=#net24}
N 5080 -940 5080 -740 {lab=#net23}
N 4980 -1040 4980 -740 {lab=#net14}
N 4880 -1140 4880 -740 {lab=#net22}
N 4480 -1540 4480 -740 {lab=#net15}
N 4580 -1440 4580 -740 {lab=#net12}
N 4680 -1340 4680 -740 {lab=#net11}
N 4780 -1240 4780 -740 {lab=#net21}
N 270 -950 300 -950 {lab=VSS}
N 270 -930 300 -930 {lab=VDD}
N 1320 -360 1340 -360 {lab=CLK}
N 820 -700 820 -680 {lab=VDD}
N 800 -700 820 -700 {lab=VDD}
N 860 -700 860 -680 {lab=VDD}
N 860 -700 880 -700 {lab=VDD}
N 4070 -620 4070 -600 {lab=amp_out}
N 4050 -600 4070 -600 {lab=amp_out}
N 4070 -600 4400 -600 {lab=amp_out}
N 4460 -600 4480 -600 {lab=#net10}
N 990 -630 1400 -630 {lab=#net25}
N 990 -470 1050 -470 {lab=!clk}
N 990 -510 1320 -510 {lab=CLK}
N 1010 -430 1010 -130 {lab=!ena}
N 990 -430 1010 -430 {lab=!ena}
N 1300 -130 1320 -130 {lab=ENA}
N 1010 -130 1070 -130 {lab=!ena}
N 270 -910 300 -910 {lab=ENA}
N 1220 -80 1220 -60 {lab=VSS}
N 1220 -200 1220 -180 {lab=VDD}
N 2510 -120 2530 -120 {lab=!ena}
N 1780 -510 1780 -490 {lab=!ena}
N 3580 -510 3580 -490 {lab=!ena}
N 3880 -530 3880 -510 {lab=!ena}
N 5180 -430 5240 -430 {lab=VSS}
N 5180 -400 5180 -380 {lab=VSS}
N 5120 -430 5140 -430 {lab=!ena}
C {/headless/eda/Hall_Xschem_Logic/Hall_Sensor.sym} 510 -570 0 0 {name=x1}
C {/headless/eda/Hall_Xschem_Logic/Rotator.sym} 840 -550 0 0 {name=x2}
C {lab_pin.sym} 880 -700 0 1 {name=p2 sig_type=std_logic lab=VDD}
C {sg13g2_pr/cap_cmim.sym} 1560 -500 0 0 {name=C2
model=cap_cmim
w=1e-5
l=1e-5
m=1
spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 1560 -700 2 0 {name=C3
model=cap_cmim
w=1e-5
l=1e-5
m=1
spiceprefix=X}
C {lab_pin.sym} 1050 -470 0 1 {name=p7 sig_type=std_logic lab=!clk}
C {lab_pin.sym} 1560 -650 0 1 {name=p8 sig_type=std_logic lab=out_p}
C {lab_pin.sym} 1560 -560 0 1 {name=p9 sig_type=std_logic lab=out_n}
C {/headless/eda/Hall_Xschem_Logic/Inverter.sym} 1220 -360 0 1 {name=x4}
C {lab_pin.sym} 1220 -430 0 1 {name=p1 sig_type=std_logic lab=VDD}
C {/headless/eda/Hall_Xschem_Logic/Simple_OTA.sym} 3900 -600 0 0 {name=x3}
C {lab_pin.sym} 3920 -680 0 1 {name=p3 sig_type=std_logic lab=VDD}
C {sg13g2_pr/rhigh.sym} 1430 -570 1 0 {name=R3
w=0.5e-6
l=10e-6
model=rhigh
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 1430 -630 3 0 {name=R1
w=0.5e-6
l=10e-6
model=rhigh
body=GND
spiceprefix=X
b=0
m=1
}
C {lab_pin.sym} 3510 -630 0 0 {name=p10 sig_type=std_logic lab=filter3_p}
C {lab_pin.sym} 3510 -570 0 0 {name=p11 sig_type=std_logic lab=filter3_n}
C {lab_pin.sym} 1860 -690 0 1 {name=p5 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2190 -750 0 1 {name=p17 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1980 -700 0 0 {name=p18 sig_type=std_logic lab=amp_p}
C {lab_pin.sym} 1980 -480 0 0 {name=p19 sig_type=std_logic lab=amp_n}
C {lab_pin.sym} 2190 -530 0 1 {name=p20 sig_type=std_logic lab=VDD}
C {sg13g2_pr/cap_cmim.sym} 2420 -640 0 0 {name=C6
model=cap_cmim
w=2.5e-5
l=2.5e-5
m=1
spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 2420 -420 0 0 {name=C4
model=cap_cmim
w=2.5e-5
l=2.5e-5
m=1
spiceprefix=X}
C {/headless/eda/Hall_Xschem_Logic/OTA-C.sym} 2170 -450 0 0 {name=x9}
C {/headless/eda/Hall_Xschem_Logic/OTA-C.sym} 2170 -670 0 0 {name=x7}
C {lab_pin.sym} 2420 -700 0 0 {name=p23 sig_type=std_logic lab=filter1_p}
C {lab_pin.sym} 2420 -480 0 0 {name=p24 sig_type=std_logic lab=filter1_n}
C {/headless/eda/Hall_Xschem_Logic/Bias_Gen.sym} 2610 -140 0 0 {name=x5}
C {lab_pin.sym} 2120 -350 0 0 {name=p12 sig_type=std_logic lab=OTA_C_Bias}
C {lab_pin.sym} 2650 -230 0 1 {name=p15 sig_type=std_logic lab=OTA_C_Bias}
C {lab_pin.sym} 2120 -570 0 0 {name=p16 sig_type=std_logic lab=OTA_C_Bias}
C {lab_pin.sym} 2570 -230 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2640 -750 0 1 {name=p28 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2640 -530 0 1 {name=p29 sig_type=std_logic lab=VDD}
C {sg13g2_pr/cap_cmim.sym} 2870 -640 0 0 {name=C8
model=cap_cmim
w=2.5e-5
l=2.5e-5
m=1
spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 2870 -420 0 0 {name=C9
model=cap_cmim
w=2.5e-5
l=2.5e-5
m=1
spiceprefix=X}
C {/headless/eda/Hall_Xschem_Logic/OTA-C.sym} 2620 -450 0 0 {name=x11}
C {/headless/eda/Hall_Xschem_Logic/OTA-C.sym} 2620 -670 0 0 {name=x12}
C {lab_pin.sym} 2570 -350 0 0 {name=p30 sig_type=std_logic lab=OTA_C_Bias}
C {lab_pin.sym} 2570 -570 0 0 {name=p31 sig_type=std_logic lab=OTA_C_Bias}
C {lab_pin.sym} 2870 -700 0 0 {name=p13 sig_type=std_logic lab=filter2_p}
C {lab_pin.sym} 2870 -480 0 0 {name=p14 sig_type=std_logic lab=filter2_n}
C {lab_pin.sym} 3090 -750 0 1 {name=p21 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 3090 -530 0 1 {name=p22 sig_type=std_logic lab=VDD}
C {sg13g2_pr/cap_cmim.sym} 3320 -640 0 0 {name=C5
model=cap_cmim
w=2.5e-5
l=2.5e-5
m=1
spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 3320 -420 0 0 {name=C7
model=cap_cmim
w=2.5e-5
l=2.5e-5
m=1
spiceprefix=X}
C {/headless/eda/Hall_Xschem_Logic/OTA-C.sym} 3070 -450 0 0 {name=x8}
C {/headless/eda/Hall_Xschem_Logic/OTA-C.sym} 3070 -670 0 0 {name=x10}
C {lab_pin.sym} 3020 -350 0 0 {name=p26 sig_type=std_logic lab=OTA_C_Bias}
C {lab_pin.sym} 3020 -570 0 0 {name=p27 sig_type=std_logic lab=OTA_C_Bias}
C {lab_pin.sym} 3660 -690 0 1 {name=p32 sig_type=std_logic lab=VDD}
C {sg13g2_pr/rhigh.sym} 5180 -550 2 1 {name=R2
w=0.5e-6
l=194e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 5130 -600 1 0 {name=R4
w=0.5e-6
l=10e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 5030 -600 1 0 {name=R5
w=0.5e-6
l=13e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4930 -600 1 0 {name=R6
w=0.5e-6
l=47.539e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4830 -600 1 0 {name=R7
w=0.5e-6
l=33.956e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4730 -600 1 0 {name=R8
w=0.5e-6
l=20.896e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4630 -600 1 0 {name=R9
w=0.5e-6
l=16.702e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4530 -600 1 0 {name=R10
w=0.5e-6
l=20.677e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4430 -600 1 0 {name=R11
w=0.5e-6
l=15.075e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {/headless/eda/Hall_Xschem_Logic/Schmitt_Comparator.sym} 4670 -1440 0 0 {name=x14}
C {lab_pin.sym} 4670 -1510 0 1 {name=p33 sig_type=std_logic lab=VDD}
C {iopin.sym} 4760 -1440 0 0 {name=p34 lab=COMP2}
C {/headless/eda/Hall_Xschem_Logic/Schmitt_Comparator.sym} 4770 -1340 0 0 {name=x15}
C {lab_pin.sym} 4770 -1410 0 1 {name=p35 sig_type=std_logic lab=VDD}
C {iopin.sym} 4860 -1340 0 0 {name=p36 lab=COMP3}
C {/headless/eda/Hall_Xschem_Logic/Schmitt_Comparator.sym} 4870 -1240 0 0 {name=x16}
C {lab_pin.sym} 4870 -1310 0 1 {name=p37 sig_type=std_logic lab=VDD}
C {iopin.sym} 4960 -1240 0 0 {name=p38 lab=COMP4}
C {/headless/eda/Hall_Xschem_Logic/Schmitt_Comparator.sym} 4970 -1140 0 0 {name=x17}
C {lab_pin.sym} 4970 -1210 0 1 {name=p39 sig_type=std_logic lab=VDD}
C {iopin.sym} 5060 -1140 0 0 {name=p40 lab=COMP5}
C {/headless/eda/Hall_Xschem_Logic/Schmitt_Comparator.sym} 5070 -1040 0 0 {name=x18}
C {lab_pin.sym} 5070 -1110 0 1 {name=p41 sig_type=std_logic lab=VDD}
C {iopin.sym} 5160 -1040 0 0 {name=p42 lab=COMP6}
C {/headless/eda/Hall_Xschem_Logic/Schmitt_Comparator.sym} 5170 -940 0 0 {name=x19}
C {lab_pin.sym} 5170 -1010 0 1 {name=p43 sig_type=std_logic lab=VDD}
C {iopin.sym} 5260 -940 0 0 {name=p44 lab=COMP7}
C {/headless/eda/Hall_Xschem_Logic/Schmitt_Comparator.sym} 5270 -840 0 0 {name=x20}
C {lab_pin.sym} 5270 -910 0 1 {name=p45 sig_type=std_logic lab=VDD}
C {iopin.sym} 5360 -840 0 0 {name=p46 lab=COMP8}
C {/headless/eda/Hall_Xschem_Logic/Schmitt_Comparator.sym} 4570 -1540 0 0 {name=x21}
C {lab_pin.sym} 4570 -1610 0 1 {name=p47 sig_type=std_logic lab=VDD}
C {iopin.sym} 4660 -1540 0 0 {name=p48 lab=COMP1}
C {sg13g2_pr/cap_cmim.sym} 4050 -530 0 0 {name=C17
model=cap_cmim
w=5e-6
l=5e-6
m=1
spiceprefix=X}
C {sg13g2_pr/rhigh.sym} 4480 -710 2 0 {name=R12
w=0.5e-6
l=6e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4580 -710 2 0 {name=R13
w=0.5e-6
l=6e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4680 -710 2 0 {name=R14
w=0.5e-6
l=6e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4780 -710 2 0 {name=R15
w=0.5e-6
l=6e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4880 -710 2 0 {name=R16
w=0.5e-6
l=6e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 4980 -710 2 0 {name=R17
w=0.5e-6
l=6e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 5080 -710 2 0 {name=R18
w=0.5e-6
l=6e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 5180 -710 2 0 {name=R19
w=0.5e-6
l=6e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {iopin.sym} 300 -950 0 0 {name=p49 lab=VSS}
C {lab_pin.sym} 270 -950 0 0 {name=p50 sig_type=std_logic lab=VSS}
C {iopin.sym} 300 -930 0 0 {name=p51 lab=VDD}
C {lab_pin.sym} 270 -930 0 0 {name=p52 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1220 -290 0 0 {name=p53 sig_type=std_logic lab=VSS}
C {iopin.sym} 1340 -360 0 0 {name=p54 lab=CLK}
C {lab_pin.sym} 1560 -430 0 0 {name=p55 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1580 -750 0 1 {name=p56 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1840 -510 0 0 {name=p57 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2170 -370 0 0 {name=p58 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2170 -590 0 0 {name=p59 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2610 -70 0 0 {name=p60 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2620 -370 0 0 {name=p61 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2620 -590 0 0 {name=p62 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2870 -370 0 0 {name=p63 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2870 -590 0 0 {name=p64 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3070 -370 0 0 {name=p65 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3070 -590 0 0 {name=p66 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2420 -370 0 0 {name=p67 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2420 -590 0 0 {name=p68 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3320 -370 0 0 {name=p69 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3320 -590 0 0 {name=p70 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3640 -510 0 0 {name=p71 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3920 -530 0 1 {name=p72 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4050 -480 0 0 {name=p73 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5270 -770 0 0 {name=p75 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5170 -870 0 0 {name=p76 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5070 -970 0 0 {name=p77 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4970 -1070 0 0 {name=p78 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4870 -1170 0 0 {name=p79 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4770 -1270 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4670 -1370 0 0 {name=p81 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4570 -1470 0 0 {name=p82 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 800 -700 0 0 {name=p83 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 840 -400 0 0 {name=p84 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4070 -620 1 0 {name=p4 sig_type=std_logic lab=amp_out}
C {/headless/eda/Hall_Xschem_Logic/Small_Differential_Amplifier.sym} 1730 -710 0 0 {name=x22}
C {/headless/eda/Hall_Xschem_Logic/Small_Differential_Amplifier.sym} 3530 -710 0 0 {name=x6}
C {/headless/eda/Hall_Xschem_Logic/Inverter.sym} 1220 -130 0 1 {name=x13}
C {iopin.sym} 300 -910 0 0 {name=p85 lab=ENA}
C {lab_pin.sym} 1010 -290 0 1 {name=p6 sig_type=std_logic lab=!ena}
C {lab_pin.sym} 270 -910 0 0 {name=p86 sig_type=std_logic lab=ENA}
C {lab_pin.sym} 1320 -130 0 1 {name=p87 sig_type=std_logic lab=ENA}
C {lab_pin.sym} 1220 -60 0 0 {name=p88 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1220 -200 0 1 {name=p89 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2510 -120 0 0 {name=p90 sig_type=std_logic lab=!ena}
C {lab_pin.sym} 1780 -490 2 1 {name=p91 sig_type=std_logic lab=!ena}
C {lab_pin.sym} 3580 -490 2 1 {name=p92 sig_type=std_logic lab=!ena}
C {lab_pin.sym} 3880 -510 2 1 {name=p93 sig_type=std_logic lab=!ena}
C {sg13g2_pr/sg13_lv_nmos.sym} 5160 -430 0 0 {name=M1
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 5240 -430 0 1 {name=p94 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5180 -380 0 0 {name=p74 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5120 -430 0 0 {name=p95 sig_type=std_logic lab=ENA}
